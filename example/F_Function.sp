********************************************************************************
* SPICE netlist generated by Tanner Verify's NetList Extractor
*
* Extract Date/Time:	Fri May 28 17:30:51 2021
* L-Edit Version:		L-Edit Win64 2019.2.20190514.21:14:33
*
* Rule Set Name:
* TDB File Name:		C:\Users\Mobin\Desktop\example\F_Function.tdb
* PX Command File:
* Command File:		C:\Users\Mobin\Desktop\example\MHP_NS8.EXT
* Cell Name:			F_Function
* Write Flat:			NO
********************************************************************************
.include 'mosistsmc180.lib'

*.model NMOS
*.model PMOS

****************************************
.param SUPPLY=1.8

*Voltage Sources
VDD VDD GND 'SUPPLY'
VA  A   GND PULSE 0 'SUPPLY' 10NS 100PS 100PS 10NS 20NS 	*input line: square wave, amp. rise t, fall t, on t, period
VB  B   GND PULSE 0 'SUPPLY' 20NS 100PS 100PS 20NS 40NS 	*input line: square wave, amp. rise t, fall t, on t, period
VC  C   GND PULSE 0 'SUPPLY' 25NS 100PS 100PS 30NS 60NS 	*input line: square wave, amp. rise t, fall t, on t, period
VD  D   GND PULSE 0 'SUPPLY' 30NS 100PS 100PS 40NS 80NS 	*input line: square wave, amp. rise t, fall t, on t, period

M1 1 C GND    GND NMOS l=6e-07 w=1.8e-06 ad=1.62e-12 as=3.24e-12 pd=3.6e-06 ps=7.2e-06  $ (-0.6 -0.9 0 0.9)
M2 OUTPUT A 1 GND NMOS l=6e-07 w=1.8e-06 ad=1.62e-12 as=1.62e-12 pd=3.6e-06 ps=3.6e-06  $ (1.8 -0.9 2.4 0.9)
M3 1 B OUTPUT GND NMOS l=6e-07 w=1.8e-06 ad=1.62e-12 as=1.62e-12 pd=3.6e-06 ps=3.6e-06  $ (4.2 -0.9 4.8 0.9)
M4 GND D 1    GND NMOS l=6e-07 w=1.8e-06 ad=3.24e-12 as=1.62e-12 pd=7.2e-06 ps=3.6e-06  $ (6.6 -0.9 7.2 0.9)
M5 VDD C 2    VDD PMOS l=6e-07 w=1.8e-06 ad=1.62e-12 as=3.24e-12 pd=3.6e-06 ps=7.2e-06  $ (-0.6 6.3 0 8.1)
M6 3 A VDD    VDD PMOS l=6e-07 w=1.8e-06 ad=1.62e-12 as=1.62e-12 pd=3.6e-06 ps=3.6e-06  $ (1.8 6.3 2.4 8.1)
M7 OUTPUT B 3 VDD PMOS l=6e-07 w=1.8e-06 ad=1.62e-12 as=1.62e-12 pd=3.6e-06 ps=3.6e-06  $ (4.2 6.3 4.8 8.1)
M8 2 D OUTPUT VDD PMOS l=6e-07 w=1.8e-06 ad=3.24e-12 as=1.62e-12 pd=7.2e-06 ps=3.6e-06  $ (6.6 6.3 7.2 8.1)

* Top level device count
* M(NMOS)		4
* M(PMOS)		4
* Number of devices:	8
* Number of nodes:	10

*Output capacitor with size C=100fF
CLoud OUTPUT GND 70fF

*extra control information---------------------
.options post=2 nomod
.op
*analysis--------------------------------------
.TRAN 20ps 100ns * transient analysis: Step end_time
