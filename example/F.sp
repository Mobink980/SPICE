********************************************************************************
* SPICE netlist generated by Tanner Verify's NetList Extractor
*
* Extract Date/Time:	Fri May 28 17:30:51 2021
* L-Edit Version:		L-Edit Win64 2019.2.20190514.21:14:33
*
* Rule Set Name:
* TDB File Name:		C:\Users\Mobin\Desktop\example\F_Function.tdb
* PX Command File:
* Command File:		C:\Users\Mobin\Desktop\example\MHP_NS8.EXT
* Cell Name:			F_Function
* Write Flat:			NO
********************************************************************************
.include 'mosistsmc180.lib'

*.model NMOS
*.model PMOS

****************************************
.param SUPPLY=1.8
.param WN=0.36u
.param WP=0.72u
.param LSD=0.36u

*Voltage Sources
VDD VDD GND 'SUPPLY'
VA  A   GND PULSE 0 'SUPPLY' 10NS 100PS 100PS 5NS  10NS 	*input line: square wave, amp. rise t, fall t, on t, period
VB  B   GND PULSE 0 'SUPPLY' 20NS 100PS 100PS 10NS 20NS 	*input line: square wave, amp. rise t, fall t, on t, period
VC  C   GND PULSE 0 'SUPPLY' 25NS 100PS 100PS 20NS 40NS 	*input line: square wave, amp. rise t, fall t, on t, period
VD  D   GND PULSE 0 'SUPPLY' 30NS 100PS 100PS 30NS 50NS 	*input line: square wave, amp. rise t, fall t, on t, period

M1 1 C GND    GND NMOS L=.18u W='WN' AS='WN*LSD' PS='2*WN+2*LSD' AD='WN*LSD' PD='2*WN+2*LSD'
M2 OUTPUT A 1 GND NMOS L=.18u W='WN' AS='WN*LSD' PS='2*WN+2*LSD' AD='WN*LSD' PD='2*WN+2*LSD'
M3 1 B OUTPUT GND NMOS L=.18u W='WN' AS='WN*LSD' PS='2*WN+2*LSD' AD='WN*LSD' PD='2*WN+2*LSD'
M4 GND D 1    GND NMOS L=.18u W='WN' AS='WN*LSD' PS='2*WN+2*LSD' AD='WN*LSD' PD='2*WN+2*LSD'
M5 VDD C 2    VDD PMOS L=.18u W='WP' AS='WP*LSD' PS='2*WP+2*LSD' AD='WP*LSD' PD='2*WP+2*LSD'
M6 3 A VDD    VDD PMOS L=.18u W='WP' AS='WP*LSD' PS='2*WP+2*LSD' AD='WP*LSD' PD='2*WP+2*LSD'
M7 OUTPUT B 3 VDD PMOS L=.18u W='WP' AS='WP*LSD' PS='2*WP+2*LSD' AD='WP*LSD' PD='2*WP+2*LSD'
M8 2 D OUTPUT VDD PMOS L=.18u W='WP' AS='WP*LSD' PS='2*WP+2*LSD' AD='WP*LSD' PD='2*WP+2*LSD'

* Top level device count
* M(NMOS)		4
* M(PMOS)		4
* Number of devices:	8
* Number of nodes:	10

*Output capacitor with size C=100fF
CLoud OUTPUT GND 100fF

*extra control information---------------------
.options post=2 nomod
.op
*analysis--------------------------------------
.TRAN 10ps 100ns * transient analysis: Step end_time
